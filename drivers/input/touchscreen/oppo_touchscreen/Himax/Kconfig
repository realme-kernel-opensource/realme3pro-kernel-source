## drivers/input/touchscreen/oppo_touchscreen/Himax/Kconfig
```kconfig
source "drivers/input/touchscreen/oppo_touchscreen/Himax/hx83112a_noflash/Kconfig"
```
